<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>168059000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>30000000</value></param>
<param><key>step</key><value>12500</value></param>
<param><key>stop</key><value>300000000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>-30</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-60</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>195312</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_ampl</value></param>
<param><key>value</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_ampl</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>-90</value></param>
</block>
<block>
<key>analog_nbfm_tx</key>
<param><key>id</key><value>analog_nbfm_tx_0</value></param>
<param><key>audio_rate</key><value>32000</value></param>
<param><key>max_dev</key><value>5e3</value></param>
<param><key>quad_rate</key><value>640000</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>880</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>32000</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_divide_xx</key>
<param><key>id</key><value>blocks_divide_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>pow(10.0,rx_gain / 10.0)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_1</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymin</key><value>-60</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_ampl</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_nbfm_tx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>analog_nbfm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_nlog10_ff_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_1</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
